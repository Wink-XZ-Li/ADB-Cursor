# Keil uVision project ADB-Cursor.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC95F8763 SC95Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x1FFF) CLOCK(32000000)
  output: Stage4B +hex
  c flags: Optimize=8 SizeSpeed=1
  c misc: OMF2 INTVECTOR(0x1000)
  c include: .\firmware\include;.\firmware\bsp;.\firmware\app;.\firmware\third_party\sinone;.\firmware\third_party\sense_lib
  group Source Group 1
    ./: STARTUP.A51
  group Firmware
    ./firmware/app/: main.c disp_ui.c hmi.c keys.c pwr_link.c ir_link.c tuya_link.c nvm.c ota_dl.c
    ./firmware/bsp/: log_uart.c timebase.c tm1640.c beep.c pwr_uart.c ir_rx.c ntc.c wifi_uart.c eeprom.c iap.c
    ./firmware/third_party/sense_lib/: TKDriver.C SC95F8X6X_HighSensitive.LIB
